# IAR project backplane.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1765 NXP LPC1765
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: Debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: backplane_debug.hex
  ILINK.IlinkOutputFile: backplane.out
  ILINK.IlinkIcfFile: program_4000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: Release
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: backplane_release.hex
configuration boot_loader (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: boot_loader
  OBJCOPY.OOCOutputFile: backplane_bootloader.hex
  ILINK.IlinkIcfFile: boot_loader_0000.icf
  group (top)
    src/: adc.c backplane.h config.h console.c flash.c gpio.c i2c.c IAP.c IAP.h ina219.c init.c ISR.c LPC1700.h LPC1700PinCfg.c LPC1700PinCfg.h main.c protocol.c rs485.c Startup.s step_motor.c vicControl.h vicControl.s
