<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\backplane.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>backplane</project>
        <configuration>boot_loader</configuration>
      </member>
      <member>
        <project>backplane</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>backplane</project>
        <configuration>pcb_test</configuration>
      </member>
      <member>
        <project>backplane</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


